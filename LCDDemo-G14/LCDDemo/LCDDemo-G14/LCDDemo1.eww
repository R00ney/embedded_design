<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LCDDemo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\SwLEDDemo - G14\SwLEDDemo - G14\SwLEDDemo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


